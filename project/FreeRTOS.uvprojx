# Keil uVision project FreeRTOS.uvprojx, settings and files
target FreeRTOS (ARM-ADS)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.5.0
  cpu: IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: FreeRTOS +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F746xx,USE_HAL_DRIVER
  c misc: --C99
  c include: ..\STM32F7xx_HAL_Driver\Inc;..\STM32F7xx_HAL_Driver\Src;..\user;..\FreeRTOS\Source;..\FreeRTOS\Source\CMSIS_RTOS;..\FreeRTOS\Source\include;..\FreeRTOS\Source\portable\MemMang;..\FreeRTOS\Source\portable\RVDS\ARM_CM7\r0p1;..\stm32f7_discovery;..\Utilities\Fonts
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: .\Objects\FreeRTOS.sct
  group USER
    ../user/: main.c stm32f7xx_hal_msp.c startup_stm32f746xx.s stm32f7xx_it.c system_stm32f7xx.c
  group FreeRTOS
    ../FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1/: port.c
  group stm32f7_discovery
    ../stm32f7_discovery/: stm32746g_discovery_lcd.c stm32746g_discovery.c stm32746g_discovery_sdram.c
  group stm32f7_hal
    ../STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_rcc.c stm32f7xx_hal_cec.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_dma.c stm32f7xx_hal_gpio.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_can.c stm32f7xx_hal_crc.c stm32f7xx_hal_cryp.c stm32f7xx_hal_cryp_ex.c stm32f7xx_hal_dac.c stm32f7xx_hal_dac_ex.c stm32f7xx_hal_dcmi.c stm32f7xx_hal_dcmi_ex.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_eth.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_hash.c stm32f7xx_hal_hash_ex.c stm32f7xx_hal_hcd.c stm32f7xx_hal_i2s.c stm32f7xx_hal_irda.c stm32f7xx_hal_iwdg.c stm32f7xx_hal_lptim.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_nand.c stm32f7xx_hal_nor.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_rng.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_sai.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_sd.c stm32f7xx_hal_sdram.c stm32f7xx_hal_smartcard.c stm32f7xx_hal_smartcard_ex.c stm32f7xx_hal_spdifrx.c stm32f7xx_hal_spi.c stm32f7xx_hal_sram.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_usart.c stm32f7xx_hal_wwdg.c stm32f7xx_ll_fmc.c stm32f7xx_ll_sdmmc.c stm32f7xx_ll_usb.c
software components: CMSIS:CORE 3.40.0
